# Keil uVision project ble_app_uart.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_InternalDeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../: ble_nus.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../../Source/app_common/: app_timer.c app_fifo.c app_gpiote.c
    ../: app_uart_fifo_mod.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_InternalDeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
